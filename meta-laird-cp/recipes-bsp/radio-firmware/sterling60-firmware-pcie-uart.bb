SUMMARY = "Laird Connectivity Sterling 60 Firmware PCIE-UART"

require radio-firmware-60.inc ../radio-stack-sterling-60-version.inc
