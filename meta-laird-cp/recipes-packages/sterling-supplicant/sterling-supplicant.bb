SUMMARY = "Laird Connectivity Wi-Fi 60 Sterling Supplicant"

require sterling-supplicant.inc ../radio-stack-sterling-60-version.inc
