require lrd-networkmanager.inc ../radio-stack-sterling-60-version.inc