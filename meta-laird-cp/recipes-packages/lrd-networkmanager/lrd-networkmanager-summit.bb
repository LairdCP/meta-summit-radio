require lrd-networkmanager.inc ../radio-stack-summit-60-version.inc
