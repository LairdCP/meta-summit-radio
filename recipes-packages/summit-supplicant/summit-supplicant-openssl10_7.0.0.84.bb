include summit-supplicant.inc

OPENSSLVER = "_openssl_1_0_2"

DEPENDS += "openssl10"
