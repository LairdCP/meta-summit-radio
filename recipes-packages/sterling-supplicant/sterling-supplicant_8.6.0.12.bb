include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi 60 Sterling Supplicant"

SRC_URI =+ "${LRD_60_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "9ffcab2fe619165fc717e514953cafcd"
SRC_URI[sha256sum] = "131a1afde04545a62532ae58195394ba044664e8f4c083840c210d098e47386f"
