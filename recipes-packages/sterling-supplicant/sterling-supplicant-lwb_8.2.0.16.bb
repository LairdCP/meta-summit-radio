include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi LWB Sterling Supplicant"

SRC_URI =+ "${LRD_LWB_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "358b73d0b9a46a23043c8511324bc26c"
SRC_URI[sha256sum] = "6acd73c7de80ca9f9e337b5dd0ad10fba34a7fb93450d3b04b311578dfbfa511"
