include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi LWB Sterling Supplicant"

SRC_URI =+ "${LRD_LWB_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "28e69c4d1d7262ed4378175e8c775bcf"
SRC_URI[sha256sum] = "dccdda14d2c255dbd428f6388e482f33f9b34047410b68209803967cbd2eb57a"
