include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi LWB Sterling Supplicant"

SRC_URI =+ "${LRD_LWB_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "c8c228045b9fbd98be692aebfd063038"
SRC_URI[sha256sum] = "d922546a619b0dc9ed019636944c4e79a52234c6a49364320e02282e2fd9e169"
