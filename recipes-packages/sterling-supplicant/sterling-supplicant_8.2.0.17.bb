include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi 60 Sterling Supplicant"

SRC_URI =+ "${LRD_60_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "210db7688e83cd527646bf58760cb44b"
SRC_URI[sha256sum] = "569f5d1239ac38b6999f5630f3ebdfd974acbff7e665df36def763901b8f9e33"
