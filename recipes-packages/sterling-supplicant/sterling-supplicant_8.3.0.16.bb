include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi 60 Sterling Supplicant"

SRC_URI =+ "${LRD_60_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "c2bb6860ef696a8ae212991d1d0534a7"
SRC_URI[sha256sum] = "f90af9e7923f6baf584f18bebe093799d8a2f922dd3e8c0577199949c729ba04"
