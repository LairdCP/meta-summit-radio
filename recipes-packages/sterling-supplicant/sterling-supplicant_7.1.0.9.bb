include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi 60 Sterling Supplicant"

SRC_URI =+ "${LRD_60_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "3fe2d4f67b000090060a81662131ce27"
SRC_URI[sha256sum] = "aa81bff072157b1d58ee30fbb84b4faaece6b5e94ffe2a1092bad5f6dcaf25fa"
