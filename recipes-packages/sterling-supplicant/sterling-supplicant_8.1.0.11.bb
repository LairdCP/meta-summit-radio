include sterling-supplicant.inc

SUMMARY = "Laird Connectivity Wi-Fi 60 Sterling Supplicant"

SRC_URI =+ "${LRD_60_URI_BASE}/sterling_supplicant-src-${PV}.tar.gz"

SRC_URI[md5sum] = "6199c7180af82c06190f90a3696c3659"
SRC_URI[sha256sum] = "f3a03e1a54ca523e6f65537271e51968f84d0e1b34132880a2e59241cf754e9c"
