SRC_URI_remove_class-target = "file://debian1.0.2/soname.patch"
