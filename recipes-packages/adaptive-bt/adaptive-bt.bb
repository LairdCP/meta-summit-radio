SUMMARY = "Laird Connectivity Bluetooth Summit 60 Auto World-Wide Mode"

require adaptive-bt.inc radio-stack-summit-60-version.inc
