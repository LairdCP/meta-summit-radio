include adaptive-ww.inc

OPENSSLVER = ""

RDEPENDS_${PN} += "libcrypto (>= 1.1.0)"
