SUMMARY = "Laird Connectivity Wi-Fi Summit 60 Manufacturing tools"

require mfg60n.inc radio-stack-summit-60-version.inc
