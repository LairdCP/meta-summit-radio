SUMMARY = "Laird Connectivity Wi-Fi Sterling 60 Manufacturing tools"

require mfg60n.inc radio-stack-sterling-60-version.inc
