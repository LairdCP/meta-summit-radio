SUMMARY = "Summit Network Manager for TI"

require summit-networkmanager.inc radio-stack-ti-version.inc
