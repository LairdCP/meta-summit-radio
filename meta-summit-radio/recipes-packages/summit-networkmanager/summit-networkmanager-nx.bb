require summit-networkmanager.inc radio-stack-nx-version.inc
