require summit-networkmanager.inc radio-stack-su60-version.inc
