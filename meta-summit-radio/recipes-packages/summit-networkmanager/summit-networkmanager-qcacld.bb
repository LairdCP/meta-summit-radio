require summit-networkmanager.inc radio-stack-qcacld-version.inc
