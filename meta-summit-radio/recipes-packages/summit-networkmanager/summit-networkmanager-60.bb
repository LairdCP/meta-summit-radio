require summit-networkmanager.inc radio-stack-60-version.inc
