SUMMARY = "Summit Wi-Fi 60 Sterling Supplicant"

require sterling-supplicant.inc radio-stack-st60-version.inc
