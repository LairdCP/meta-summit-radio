SUMMARY = "Summit Wi-Fi LWB Sterling Supplicant"

require sterling-supplicant.inc radio-stack-lwb-version.inc
