SUMMARY = "Summit Wi-Fi Regulatory Test tools for LWB+"

REG_NAME = "regLWBplus"

require reg-lwb.inc
