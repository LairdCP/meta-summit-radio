SUMMARY = "Summit Bluetooth 60 Auto World-Wide Mode"

require summit-adaptive-bt.inc radio-stack-60-version.inc
