require adaptive-bt.inc radio-stack-60-version.inc
