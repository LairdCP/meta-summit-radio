SUMMARY = "Summit Wi-Fi Regulatory Test tools for IF513"

REG_NAME = "regIF513"

require reg-lwb.inc
