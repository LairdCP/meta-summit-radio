SUMMARY = "Summit Wi-Fi Regulatory Test tools for LWB+"

REG_NAME = "regLWB5plus"

require reg-lwb.inc
