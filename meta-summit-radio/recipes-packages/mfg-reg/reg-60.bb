SUMMARY = "Summit Wi-Fi Regulatory Test tools"

require mfg60n.inc radio-stack-60-version.inc
