SUMMARY = "Summit Wi-Fi Sterling 60 Manufacturing tools"

require mfg60n.inc radio-stack-st60-version.inc
