SUMMARY = "Wi-Fi Summit Supplicant Libraries for Sona NX"

require summit-supplicant-libs.inc radio-stack-nx-version.inc
