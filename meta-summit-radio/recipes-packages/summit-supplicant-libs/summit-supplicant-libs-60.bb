SUMMARY = "Wi-Fi Summit Supplicant Libraries for 60"

require summit-supplicant-libs.inc radio-stack-60-version.inc
