SUMMARY = "Wi-Fi Summit Supplicant Libraries for QCACLD"

require summit-supplicant-libs.inc radio-stack-qcacld-version.inc
