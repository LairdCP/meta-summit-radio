SUMMARY = "Wi-Fi Summit Supplicant Libraries for LWB"

require summit-supplicant-libs.inc radio-stack-lwb-version.inc
