SUMMARY = "Summit Supplicant for LWB and IF"

require summit-supplicant-modern.inc radio-stack-lwb-version.inc
