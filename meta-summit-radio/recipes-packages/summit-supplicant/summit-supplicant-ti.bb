SUMMARY = "Summit Supplicant for TI"

require summit-supplicant-modern.inc radio-stack-ti-version.inc
