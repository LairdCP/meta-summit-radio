require summit-supplicant-modern.inc radio-stack-60-version.inc

RRECOMMENDS:${PN} += "summit-supplicant-libs-60"
