require summit-supplicant-modern.inc radio-stack-lwb-version.inc

RRECOMMENDS:${PN} += "summit-supplicant-libs-lwb"
