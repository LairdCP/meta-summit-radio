require summit-supplicant-modern.inc radio-stack-qcacld-version.inc
