SUMMARY = "Summit Supplicant for NX"

require summit-supplicant-modern.inc radio-stack-nx-version.inc
