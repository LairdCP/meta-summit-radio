require summit-hostapd.inc radio-stack-nx-version.inc
