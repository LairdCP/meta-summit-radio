SUMMARY = "Summit hostapd for TI"

require summit-hostapd.inc radio-stack-ti-version.inc
