SUMMARY = "Summit hostapd for 60"

require summit-hostapd.inc radio-stack-60-version.inc
