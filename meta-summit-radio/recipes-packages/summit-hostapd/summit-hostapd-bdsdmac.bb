require summit-hostapd.inc radio-stack-bdsdmac-version.inc
