SUMMARY = "Summit hostapd for LWB and IF"

require summit-hostapd.inc radio-stack-lwb-version.inc
