require summit-hostapd.inc radio-stack-qcacld-version.inc
