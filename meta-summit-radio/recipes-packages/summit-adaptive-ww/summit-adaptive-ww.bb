require summit-adaptive-ww.inc radio-stack-60-version.inc
