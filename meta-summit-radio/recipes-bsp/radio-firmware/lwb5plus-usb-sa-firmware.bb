SUMMARY = "Summit firmware for the LWB5+ USB/USB module with a single antenna"

require radio-firmware-lwb.inc
