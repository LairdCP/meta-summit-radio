SUMMARY = "Summit firmware for the LWB5 SDIO/UART module for operation in Japan"

require radio-firmware-lwb.inc
