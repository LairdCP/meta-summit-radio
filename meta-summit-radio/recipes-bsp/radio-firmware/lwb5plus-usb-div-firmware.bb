SUMMARY = "Summit firmware for the LWB5+ USB/USB module with diversity antenna"

require radio-firmware-lwb.inc
