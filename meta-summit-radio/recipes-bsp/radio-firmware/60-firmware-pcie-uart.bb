SUMMARY = "Summit 60 Firmware PCIE-UART"

require radio-firmware-60.inc
