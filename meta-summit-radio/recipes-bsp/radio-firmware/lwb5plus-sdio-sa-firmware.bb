SUMMARY = "Summit firmware for the LWB5+ SDIO/UART module with a single antenna"

require radio-firmware-lwb.inc
