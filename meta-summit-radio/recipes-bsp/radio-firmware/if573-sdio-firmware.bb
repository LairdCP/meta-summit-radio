SUMMARY = "Summit firmware for the IF573 SDIO/UART module"

require radio-firmware-lwb.inc
