SUMMARY = "Summit SU60 Firmware PCIE-UART"

require radio-firmware-60.inc radio-stack-su60-version.inc
