SUMMARY = "Summit firmware for the LWB+ SDIO/UART module"

require radio-firmware-lwb.inc
