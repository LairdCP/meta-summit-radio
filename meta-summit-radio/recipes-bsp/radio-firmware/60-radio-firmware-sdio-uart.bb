SUMMARY = "Summit 60 Firmware SDIO-UART"

require radio-firmware-60.inc
