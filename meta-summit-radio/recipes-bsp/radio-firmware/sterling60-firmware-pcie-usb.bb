SUMMARY = "Summit Sterling 60 Firmware PCIE-USB"

require radio-firmware-60.inc radio-stack-st60-version.inc
