SUMMARY = "Summit firmware for the LWB5 SDIO/UART module for operation in the European Union"

require radio-firmware-lwb.inc
