SUMMARY = "Summit firmware for the LWB5+ SDIO/UART module with diversity antenna"

require radio-firmware-lwb.inc
