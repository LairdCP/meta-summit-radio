SUMMARY = "Summit 60 Firmware SDIO-SDIO"

require radio-firmware-60.inc
