SUMMARY = "Laird Connectivity Summit 60 Firmware USB-UART"

require radio-firmware-60.inc radio-stack-summit-60-version.inc
