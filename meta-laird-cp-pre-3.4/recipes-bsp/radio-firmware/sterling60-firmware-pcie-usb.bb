SUMMARY = "Laird Connectivity Sterling 60 Firmware PCIE-USB"

require radio-firmware-60.inc ../radio-stack-sterling-60-version.inc
