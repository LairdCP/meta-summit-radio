OPENSSLVER = ""

RDEPENDS_${PN} += "libcrypto (>= 1.1.0)"

require adaptive-ww.inc ../radio-stack-summit-60-version.inc
