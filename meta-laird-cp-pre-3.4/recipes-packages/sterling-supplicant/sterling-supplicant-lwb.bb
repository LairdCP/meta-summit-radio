SUMMARY = "Laird Connectivity Wi-Fi LWB Sterling Supplicant"

require sterling-supplicant.inc radio-stack-lwb-version.inc
