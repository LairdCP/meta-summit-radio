SUMMARY = "Laird LWB Radio Firmware for JP Regulatory Domain"

LWB_PART_NAME = "480-0116"

include lwb-radio-firmware.inc
