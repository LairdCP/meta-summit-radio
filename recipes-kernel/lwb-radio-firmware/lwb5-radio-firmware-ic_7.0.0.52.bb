SUMMARY = "Laird LWB5 Radio Firmware for IC Regulatory Domain"

LWB_PART_NAME = "480-0094"

include lwb-radio-firmware.inc
