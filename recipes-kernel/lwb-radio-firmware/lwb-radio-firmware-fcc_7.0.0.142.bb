SUMMARY = "Laird LWB Radio Firmware for FCC Regulatory Domain"

LWB_PART_NAME = "480-0079"

include lwb-radio-firmware.inc
