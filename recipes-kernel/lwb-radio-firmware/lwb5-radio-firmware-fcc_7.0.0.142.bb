SUMMARY = "Laird LWB5 Radio Firmware for FCC Regulatory Domain"

LWB_PART_NAME = "480-0081"

include lwb-radio-firmware.inc
