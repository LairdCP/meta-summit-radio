SUMMARY = "Laird LWB5 Radio Firmware for JP Regulatory Domain"

LWB_PART_NAME = "480-0095"

include lwb-radio-firmware.inc
