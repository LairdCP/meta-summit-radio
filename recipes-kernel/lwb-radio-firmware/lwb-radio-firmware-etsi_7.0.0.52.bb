SUMMARY = "Laird LWB Radio Firmware for ETSI Regulatory Domain"

LWB_PART_NAME = "480-0080"

include lwb-radio-firmware.inc
