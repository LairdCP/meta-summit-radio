SUMMARY = "Laird LWB5 Radio Firmware for ETSI Regulatory Domain"

LWB_PART_NAME = "480-0082"

include lwb-radio-firmware.inc
