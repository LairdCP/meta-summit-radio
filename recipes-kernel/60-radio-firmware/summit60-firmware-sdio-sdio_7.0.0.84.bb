SUMMARY = "Laird Summit 60 Firmware SDIO-SDIO"

SRC_URI += "${LRD_URI_LOCAL}/laird-summit60-firmware-sdio-sdio-${PV}.tar.bz2"

include radio-firmware.inc
