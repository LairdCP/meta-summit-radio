SUMMARY = "Laird Summit 60 Firmware PCIE-USB"

SRC_URI += "${LRD_URI_LOCAL}/laird-summit60-firmware-pcie-usb-${PV}.tar.bz2"

include radio-firmware.inc
