SUMMARY = "Laird Summit 60 Firmware PCIE-UART"

SRC_URI += "${LRD_URI_LOCAL}/laird-summit60-firmware-pcie-uart-${PV}.tar.bz2"

include radio-firmware.inc
