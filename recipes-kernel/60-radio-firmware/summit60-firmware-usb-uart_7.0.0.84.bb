SUMMARY = "Laird Summit 60 Firmware USB-UART"

SRC_URI += "${LRD_URI_LOCAL}/laird-summit60-firmware-usb-uart-${PV}.tar.bz2"

include radio-firmware.inc
