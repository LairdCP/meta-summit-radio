SUMMARY = "Laird Summit 60 Firmware SDIO-UART"

SRC_URI += "${LRD_URI_LOCAL}/laird-summit60-firmware-sdio-uart-${PV}.tar.bz2"

include radio-firmware.inc
