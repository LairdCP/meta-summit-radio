SUMMARY = "Laird Summit 60 Firmware SDIO-UART"

SRC_URI += "${LRD_URI_LOCAL}/laird-${PN}-${PV}.tar.bz2"

include radio-firmware.inc
