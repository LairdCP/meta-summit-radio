SUMMARY = "Laird Connectivity LWB5 Firmware for JP Regulatory Domain"

SRC_URI += "${LRD_URI_LOCAL}/laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
