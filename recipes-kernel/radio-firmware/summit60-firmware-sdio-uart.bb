SUMMARY = "Laird Connectivity Summit 60 Firmware SDIO-UART"

require radio-firmware-60.inc radio-stack-summit-60-version.inc
