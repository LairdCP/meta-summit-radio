SUMMARY = "Laird Connectivity Summit 60 Firmware PCIE-USB"

SRC_URI += "${LRD_URI_LOCAL}/laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
