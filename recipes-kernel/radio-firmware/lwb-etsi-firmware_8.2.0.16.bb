SUMMARY = "Laird Connectivity LWB firmware for SDIO/UART module for operation in European Union"

SRC_URI += "${LRD_URI_LOCAL}/laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
