SUMMARY = "Laird Connectivity LWB Firmware for ETSI Regulatory Domain"

SRC_URI += "${LRD_URI_LOCAL}/laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
