SUMMARY = "Laird Connectivity LWB5 firmware for SDIO/UART module for operation in Canada"

SRC_URI += "${LRD_URI_LOCAL}/laird-${BPN}-${PV}.tar.bz2"

include radio-firmware.inc
