SUMMARY = "Laird Connectivity Sterling 60 Firmware USB-UART"

require radio-firmware-60.inc radio-stack-sterling-60-version.inc
