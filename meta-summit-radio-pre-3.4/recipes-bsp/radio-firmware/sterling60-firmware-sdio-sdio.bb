SUMMARY = "Summit Sterling 60 Firmware SDIO-SDIO"

require radio-firmware-60.inc radio-stack-st60-version.inc
