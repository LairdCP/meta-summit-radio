SUMMARY = "Summit 60 Firmware PCIE-USB"

require radio-firmware-60.inc
