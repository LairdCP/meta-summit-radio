SUMMARY = "Summit firmware for the IF513 SDIO/UART module"

require radio-firmware-lwb.inc
