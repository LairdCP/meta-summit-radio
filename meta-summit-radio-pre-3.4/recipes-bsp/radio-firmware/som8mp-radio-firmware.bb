SUMMARY = "Summit 60 Firmware for SOM8MP"

require radio-firmware-60.inc
