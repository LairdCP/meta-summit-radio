SUMMARY = "Summit 60 Firmware USB-USB"

require radio-firmware-60.inc
