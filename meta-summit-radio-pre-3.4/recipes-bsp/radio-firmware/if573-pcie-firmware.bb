SUMMARY = "Summit firmware for the IF573 PCIE/UART module"

require radio-firmware-lwb.inc
