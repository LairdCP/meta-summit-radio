SUMMARY = "Summit firmware for the LWB SDIO/UART module for operation in Japan"

require radio-firmware-lwb.inc
