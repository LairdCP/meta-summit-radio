SUMMARY = "Summit firmware for the LWB5+ SDIO/UART M.2 module with a single antenna"

require radio-firmware-lwb.inc
