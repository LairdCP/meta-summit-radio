SUMMARY = "Summit Sterling 60 Firmware SDIO-UART"

require radio-firmware-60.inc radio-stack-st60-version.inc
