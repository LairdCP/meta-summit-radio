SUMMARY = "Summit firmware for the LWB SDIO/UART module for operation in the United States"

require radio-firmware-lwb.inc
