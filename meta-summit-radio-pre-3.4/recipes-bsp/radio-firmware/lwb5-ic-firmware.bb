SUMMARY = "Summit firmware for the LWB5 SDIO/UART module for operation in Canada"

require radio-firmware-lwb.inc
