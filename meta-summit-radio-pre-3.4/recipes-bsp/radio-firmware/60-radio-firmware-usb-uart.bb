SUMMARY = "Summit 60 Firmware USB-UART"

require radio-firmware-60.inc
