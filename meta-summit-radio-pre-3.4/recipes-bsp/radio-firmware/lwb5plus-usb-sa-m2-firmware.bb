SUMMARY = "Summit firmware for the LWB5+ USB/USB M.2 module with a single antenna"

require radio-firmware-lwb.inc
