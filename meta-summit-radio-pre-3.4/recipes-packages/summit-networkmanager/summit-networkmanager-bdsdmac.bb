require summit-networkmanager.inc radio-stack-bdsdmac-version.inc
