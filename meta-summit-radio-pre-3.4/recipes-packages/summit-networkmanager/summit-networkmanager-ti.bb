SUMMARY = "Summit Network Manager for TI"

require summit-networkmanager.inc
require radio-stack-ti-version.inc
