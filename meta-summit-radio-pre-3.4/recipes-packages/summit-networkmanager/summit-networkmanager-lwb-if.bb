SUMMARY = "Summit Network Manager for LWB and IF"

require summit-networkmanager.inc
require radio-stack-lwb-version.inc
