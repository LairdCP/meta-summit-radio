SUMMARY = "Summit Network Manager for 60"

require summit-networkmanager.inc
require radio-stack-60-version.inc
