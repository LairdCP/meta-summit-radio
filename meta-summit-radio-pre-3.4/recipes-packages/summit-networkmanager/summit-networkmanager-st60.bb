require summit-networkmanager.inc radio-stack-st60-version.inc
