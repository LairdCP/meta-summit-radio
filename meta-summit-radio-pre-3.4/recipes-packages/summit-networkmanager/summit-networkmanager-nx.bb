SUMMARY = "Summit Network Manager for NX"

require summit-networkmanager.inc
require radio-stack-nx-version.inc
