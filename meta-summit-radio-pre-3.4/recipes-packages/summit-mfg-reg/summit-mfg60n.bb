SUMMARY = "Summit Wi-Fi 60 Manufacturing tools"

require mfg60n.inc
require radio-stack-60-version.inc
