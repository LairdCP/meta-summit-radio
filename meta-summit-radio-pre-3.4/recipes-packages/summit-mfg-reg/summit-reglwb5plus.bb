SUMMARY = "Summit Wi-Fi Regulatory Test tools for LWB5+"

REG_NAME = "regLWB5plus"

require reg-lwb.inc
