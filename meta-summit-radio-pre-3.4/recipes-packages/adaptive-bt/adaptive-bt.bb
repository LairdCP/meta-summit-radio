SUMMARY = "Summit Bluetooth SU60 Auto World-Wide Mode"

require adaptive-bt.inc radio-stack-su60-version.inc
