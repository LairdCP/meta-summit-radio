SUMMARY = "Summit hostapd for NX"

require summit-hostapd.inc
require radio-stack-nx-version.inc
