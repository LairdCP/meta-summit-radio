SUMMARY = "Summit hostapd for BD SDMAC"

require summit-hostapd.inc
require radio-stack-bdsdmac-version.inc
