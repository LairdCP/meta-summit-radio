SUMMARY = "Summit hostapd for TI"

require summit-hostapd.inc
require radio-stack-ti-version.inc
