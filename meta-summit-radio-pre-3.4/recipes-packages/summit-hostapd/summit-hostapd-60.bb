require summit-hostapd.inc radio-stack-60-version.inc
