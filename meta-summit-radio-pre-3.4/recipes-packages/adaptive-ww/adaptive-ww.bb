require adaptive-ww.inc
require radio-stack-60-version.inc
