SUMMARY = "Wi-Fi Summit Supplicant Libraries for BD-SDMAC"

require summit-supplicant-libs.inc radio-stack-bdsdmac-version.inc
