SUMMARY = "Summit Wi-Fi SU60 Manufacturing tools"

require mfg60n.inc radio-stack-su60-version.inc
