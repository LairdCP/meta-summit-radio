SUMMARY = "Summit Wi-Fi ST60 Manufacturing tools"

require mfg60n.inc radio-stack-st60-version.inc
