SUMMARY = "Summit Wi-Fi Regulatory Test tools for IF573"

REG_NAME = "regIF573"

require reg-lwb.inc
