SUMMARY = "Summit Wi-Fi ST60 Sterling Supplicant"

require sterling-supplicant.inc radio-stack-60-version.inc
