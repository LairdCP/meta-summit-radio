require summit-supplicant-modern.inc radio-stack-nx-version.inc
