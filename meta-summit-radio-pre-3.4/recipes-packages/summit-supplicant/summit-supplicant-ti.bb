SUMMARY = "Summit Supplicant for TI"

require summit-supplicant-modern.inc
require radio-stack-ti-version.inc
