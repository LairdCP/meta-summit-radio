require summit-supplicant-modern.inc radio-stack-bdsdmac-version.inc

RRECOMMENDS_${PN} += "summit-supplicant-libs-bdsdmac"
