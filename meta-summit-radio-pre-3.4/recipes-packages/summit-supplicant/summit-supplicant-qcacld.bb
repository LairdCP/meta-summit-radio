require summit-supplicant-modern.inc radio-stack-qcacld-version.inc

RRECOMMENDS:${PN} += "summit-supplicant-libs-qcacld"
