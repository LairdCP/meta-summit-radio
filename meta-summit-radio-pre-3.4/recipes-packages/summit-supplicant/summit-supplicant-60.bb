require summit-supplicant-modern.inc radio-stack-60-version.inc

RRECOMMENDS_${PN} += "summit-supplicant-libs-60"
